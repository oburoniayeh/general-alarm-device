# Repository oburoniayeh/general-alarm-device

## KiCad design Hardware/GeneralPurposeAlarmDevicePCB/GeneralPurposeAlarmDevicePCB.kicad_pcb

Board: 2 copper layers, 137.1 x 83.8 mm, 153 parts (18 on the bottom side), 100 nets.

Parts:
A101: Arduino_UNO_R3_Shield; Arduino_UNO_R3_NoMountingHoles3D
BZ601: Buzzer_Adafruit_P1536A; Buzzer_12.2mm_9.7mm_7.62mm
C101, C104, C107, C113, C114: 39pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C102, C106, C109, C112, C302, C502, C601: 47uF 16V; CP_Elec_5x5.4
C103, C105, C108, C110, C111, C301, C501, C503, C602: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C702: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D101, D103, D104: Schottky 2A; D_SMB
D102, D106, D703: RED 0603; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D105: LED_T1.75_CLEAR_RED; LED_5mm_Radial
D201, D202, D203, D204, D205: LED_T1.75_CLEAR_WHITE; LED_5mm_Radial
D501: RED 0603; LED_0603_1608Metric
D701: ORANGE 0603; LED_0603_1608Metric
D702: GREEN 0603; LED_0603_1608Metric
D704: PMEG3020EP; D_SOD-128
F101, F401: Polyfuse_Small; Fuse_0603_1608Metric
H101, H102, H103, H104, H105: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J101: Barrel_Jack_Switch_SMT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
J102, J103: 0.100_2Pin; PinHeader_1x02_P2.54mm_Vertical
J105: S04B-XASK-1(LF)(SN)Rev2
J401: RJ12_6P6C_HORZ; RJ12_Amphenol_54601
J501: USB_B_Micro_Local; USB_Micro-B_Amphenol_10118194_Horizontal
J601, J602: 22-23-2021; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J701: BATT_JST; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
MF103, MF601, MF602, MF603, MF604, MF605: U_Box_V104_General_Alarm_Device_LED_Standoff
Q201, Q202, Q203, Q204, Q205: MMBT2222A-7-F; SOT-23
Q301, Q601: BSS138; SOT-23
Q302: AOSS32334C; SOT-23
Q602: DNI; SOT-23-3
R101, R305, R307, R309, R310: 1R0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R102, R505, R603: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R103, R108, R109, R304, R602, R705: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R104, R105: 39R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R106, R107, R306, R308, R506, R604: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R110, R111, R112, R202, R204, R206, R208, R210, R401, R402, R403, R404, R501, R502, R503, R605, R701, R702, R703: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R201, R203, R205, R207, R209, R301, R302, R303, R311, R312, R504: 4K7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R507, R508, R601: 1R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R704: 2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R706: 150K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV301: POT 0.375 10K; Potentiometer_Bourns_3386P_Vertical
S101: SWITCH_TACTILE_SPST-NO_0.05A_24V; Switch_Tactile_THT_6x6mm
S601: SWITCH_TACTILE_12mmx12mm_SPST-NO_0.05A_24V; SW_PUSH-12mm_WithCap_Green
T1, T2, T3: JLC_ToolingHole_0576mm
TH701: 10k Therm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP101: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP102: Vin; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP103: +5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP104: VccController; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP105: 3.3V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP201: VBus; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP202: V3; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP203: nCTS; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP401: Vcc_LCD; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP402: nINT; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP501: VccBuzzer; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U101: LM7805_TO220; TO-220-3_Horizontal_TabDown
U102: PI_ATMEGA328P-AU-InOrder; TQFP-32_7x7mm_P0.8mm
U301: PCF8574AT_3_518; SOIC-16W_7.5x10.3mm_P1.27mm
U302: LCD_20x4_Character-GPAD_SCH_LIB; LCD_2004A
U501: CH340E; MSOP-10_3x3mm_P0.5mm
U701: MCP73833; DFN-10-1EP_3x3mm_P0.5mm_EP1.7x2.5mm
XTAL101: 16MHZ 20PF HC-49S/SMD; Crystal_SMD_HC49-SD

Connections:
+5V: A101.2 (IOREF), A101.5 (+5V), C108.1, C109.1, D701.2 (A), D702.2 (A), D703.2 (A), D704.1 (K), J102.1, J105.4, Q302.2 (S), R101.2, R106.2, R110.2, R202.2, R204.2, R206.2, R208.2, R210.2, R310.2, R601.2, R603.2, TP103.1, U101.3 (VO), U701.1 (VDD1), U701.2 (VDD2)
/AlarmAudio/VccBuzzer: BZ601.1 (-), C601.1, J601.1, R506.2, R601.1, TP501.1
/LCD And I2C Interface/Vcc_LCD: C301.1, C302.1, Q302.3 (D), R301.2, R302.2, R303.2, R304.2, R306.2, R310.1, R311.2, RV301.3, TP401.1, U301.16 (VDD), U302.2 (VDD), U302.15 (A)
Attenuate: A101.19 (D4), R605.1, U102.2 (PD4)
CIPO: A101.27 (D12), R401.1, U102.16 (PB4)
COPI: A101.26 (D11), R403.1, U102.15 (PB3)
ControllerRX: A101.15 (D0/RX), R502.1, U102.30 (PD0)
ControllerTX: A101.16 (D1/TX), R503.1, U102.31 (PD1)
ControllerVcc: F401.1, J103.2, R107.1
GND: A101.6 (GND), A101.7 (GND), A101.29 (GND), C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C111.2, C112.2, C113.2, C114.2, C301.2, C302.2, C501.2, C502.2, C503.2, C601.2, C602.2, C702.2, D102.1 (K), D105.2, D106.1 (K), D501.1 (K), H101.1, H102.1, H103.1, H104.1, H105.1, J101.2, J101.3, J105.2, J401.3, J501.5 (GND), J501.6 (Shield), J602.2, J701.2, Q201.2 (E), Q202.2 (E), Q203.2 (E), Q204.2 (E), Q205.2 (E), Q301.2 (S), Q602.3 (C), R305.2, R307.2, R308.1, R309.2, R504.1, R505.1, R508.1, R704.2, R706.2, RV301.1, S101.3, S101.4, S601.3, S601.4, TH701.2, TP101.1, U101.2 (GND), U102.3 (GND), U102.5 (GND), U102.21 (GND), U301.8 (VSS), U302.1 (VSS), U302.7 (DB0), U302.8 (DB1), U302.9 (DB2), U302.10 (DB3), U302.17 (MH1), U302.18 (MH2), U302.19 (MH3), U302.20 (MH4), U501.3 (GND), U701.5 (GND)
LCD power: Q302.1 (G), U102.22 (ADC7)
Light0: A101.18 (D3), R201.2, U102.1 (PD3)
Light1: A101.20 (D5), R203.2, U102.9 (PD5)
Light2: A101.21 (D6), R205.2, U102.10 (PD6)
Light3: A101.24 (D9), R207.2, U102.13 (PB1)
Light4: A101.22 (D7), R209.2, U102.11 (PD7)
unnamed: C101.1, F101.2, J101.1, J101.4
unnamed: R306.1, R308.2, RV301.2, U302.3 (VO)
unnamed: A101.4 (3V3), TP105.1
unnamed: A101.3 (~RESET), R111.2
unnamed: BZ601.2 (+), J601.2, R507.1, R604.1
unnamed: C113.1, J105.3, R104.1
unnamed: C114.1, J105.1, R105.1
unnamed: D101.2 (A), F101.1
unnamed: D102.2 (A), R103.1
unnamed: D104.2 (A), J103.1, R107.2
unnamed: D105.1, R110.1
unnamed: D106.2 (A), R112.1
unnamed: D201.1, R202.1
unnamed: D202.1, R204.1
unnamed: D203.1, R206.1
unnamed: D204.1, R208.1
unnamed: D205.1, R210.1
unnamed: D501.2 (A), R501.2
unnamed: D701.1 (K), R701.1
unnamed: D702.1 (K), R702.1
unnamed: D703.1 (K), R703.1
unnamed: C702.1, D704.2 (A), J701.1, U701.9 (VBAT1), U701.10 (VBAT2)
unnamed: F401.2, J401.5
unnamed: J401.1, R404.2
unnamed: J401.2, R403.2
unnamed: J401.4, R402.2
unnamed: J401.6, R401.2
unnamed: J501.3 (D+), U501.1 (UD+)
unnamed: J501.2 (D-), U501.2 (UD-)
unnamed: Q201.1 (B), R201.1
unnamed: D201.2, Q201.3 (C)
unnamed: Q202.1 (B), R203.1
unnamed: D202.2, Q202.3 (C)
unnamed: Q203.1 (B), R205.1
unnamed: D203.2, Q203.3 (C)
unnamed: Q204.1 (B), R207.1
unnamed: D204.2, Q204.3 (C)
unnamed: Q205.1 (B), R209.1
unnamed: D205.2, Q205.3 (C)
unnamed: Q301.3 (D), U302.16 (K)
unnamed: Q301.1 (G), R312.1
unnamed: Q601.3 (D), R506.1, R507.2
unnamed: Q601.1 (G), Q602.1 (B), R505.2, R602.1, R605.2
unnamed: Q601.2 (S), Q602.2 (E), R508.2, R604.2
unnamed: R705.2, R706.1, TH701.1
unnamed: C104.1, U102.7 (XTAL1/PB6), XTAL101.1
unnamed: C107.1, U102.8 (XTAL2/PB7), XTAL101.2
unnamed: R303.1, R309.1, U301.1 (A0)
unnamed: R302.1, R307.1, U301.2 (A1)
unnamed: R301.1, R305.1, U301.3 (A2)
unnamed: U301.4 (P0), U302.4 (RS)
unnamed: U301.5 (P1), U302.5 (R/W)
unnamed: U301.6 (P2), U302.6 (E)
unnamed: R311.1, R312.2, U301.7 (P3)
unnamed: U301.9 (P4), U302.11 (DB4)
unnamed: U301.10 (P5), U302.12 (DB5)
unnamed: U301.11 (P6), U302.13 (DB6)
unnamed: U301.12 (P7), U302.14 (DB7)
unnamed: R304.1, TP402.1, U301.13 (~INT)
unnamed: R503.2, U501.9 (RXD)
unnamed: R501.1, U501.6 (TNOW)
unnamed: R502.2, U501.8 (TXD)
unnamed: C503.1, TP202.1, U501.10 (V3)
unnamed: R504.2, TP203.1, U501.5 (~CTS)
unnamed: R703.2, U701.7 (PG)
unnamed: R704.1, U701.6 (PROG)
unnamed: R701.2, U701.3 (STAT1)
unnamed: R702.2, U701.4 (STAT2)
unnamed: R705.1, U701.8 (THERM)
PC0: A101.9 (A0), U102.23 (PC0)
PC1: A101.10 (A1), U102.24 (PC1)
PC2: A101.11 (A2), U102.25 (PC2)
PC3: A101.12 (A3), R112.2, U102.26 (PC3)
SCL: A101.14 (SCL/A5), A101.32 (SCL/A5), R104.2, R109.2, U102.28 (PC5), U301.14 (SCL)
SDA: A101.13 (SDA/A4), A101.31 (SDA/A4), R105.2, R108.2, U102.27 (PC4), U301.15 (SDA)
SPI_SCK: A101.28 (D13), R103.2, R402.1, U102.17 (PB5)
Switch_Mute: A101.17 (D2), C602.1, J602.1, R603.1, S601.1, S601.2, U102.32 (PD2)
Tone: A101.23 (D8), R602.2, U102.12 (PB0)
VBus: C501.1, C502.1, J102.2, J501.1 (VBUS), R106.1, TP201.1, U501.7 (VCC)
VccController: A101.30 (AREF), C103.1, C106.1, C111.1, C112.1, D103.1 (K), R101.1, R102.2, R108.1, R109.1, TP104.1, U102.4 (VCC), U102.6 (VCC), U102.18 (AVCC), U102.20 (AREF)
Vin: A101.8 (VIN), C102.1, C105.1, D101.1 (K), D104.1 (K), TP102.1, U101.1 (VI)
nCS: A101.25 (D10), R404.1, U102.14 (PB2)
nRESET: C110.1, D103.2 (A), R102.1, R111.1, S101.1, S101.2, U102.29 (~RESET/PC6)
nRTS: C110.2, U501.4 (~RTS)

## Commit log

2023-05-02 PCB design for battery circuitry layout

Notices in the files:
Hardware/GeneralPurposeAlarmDevicePCB/GeneralPurposeAlarmDevicePCB.kicad_pcb:
GNU Affero General Public License v3.0
CERN Open Hardware License Version 2 - Strongly Reciprocal
